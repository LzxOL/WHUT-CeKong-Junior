# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Hardware/: key.h key.c delay.c delay.h lcd.c lcd.h shumaguan.c shumaguan.h adc.h adc.c uart.c uart.h
